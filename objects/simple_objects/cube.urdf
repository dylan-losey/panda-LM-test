Commit message: working

File: objects/simple_objects/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base: geometry collision box size=0.05 0.05 0.4; visual box size=0.05 0.05 0.4
